# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F091RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: USART +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o mult12path_m8321_bootloader.bin  D:\work\RS485_lock\mult_12path_f091_m8321_bootloader\OBJ\USART.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F051,USE_STM320518_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: .\CMIS;.\STM32F0xx_StdPeriph_Driver\inc;.\USER\inc;.\USER\contiki;D:\Keil\ARM\PACK\ARM\CMSIS\5.3.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMIS
    ./CMIS/: system_stm32f0xx.c startup_stm32f091.s
  group USER
    ./USER/src/: main.c stm32f0xx_it.c gsm_test.c app_fifo.c
  group STM32F0xx_StdPeriph_Driver
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_misc.c
  group Doc
    ./USER/src/: readme.txt
target USART-SWD (ARM-ADS)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: USART
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ropelock.bin D:\work\stm32f030\release\rope_ms5611\OBJ\USART.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F051,USE_STM320518_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK,USE_SWD_UART
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.2.0
